FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-GCC_5_3_0-Explicitely-disble-Werror-cast-qual.patch"
